# Keil uVision project Minibalance.uvproj, settings and files
target ROS_CAR (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\sys;..\USER;..\CORE;..\HARDWARE\inc;..\BALANCE\CONTROL;..\BALANCE\CONTROL;..\BALANCE\show;..\BALANCE\controls
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_md.s sys.c
  group USER
    ./: Minibalance.c delay.c
  group HARDWARE
    ../HARDWARE/src/: LED.C key.c oled.c adc.c timer.c motor.c encoder.c usart2.c usart.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/show/: show.c
